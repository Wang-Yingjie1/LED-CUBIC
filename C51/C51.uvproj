# Keil uVision project C51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Startup
    ./: STARTUP.A51
  group USER
    ./USER/: main.c bsp_ledcubic.c pattern.c
